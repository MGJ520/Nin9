# Keil uVision project HALL.uvprojx, settings and files
target HALL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F415CCT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.1.8
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: voltage_monitoring +hex
  AfterMake: fromelf --bin !L --output "../bin/firmware.bin"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F415RCT7,USE_STDPERIPH_DRIVER,AT_START_F415_V1
  c include: ..\libraries\drivers\inc;..\libraries\cmsis\cm4\core_support;..\libraries\cmsis\cm4\device_support;..\inc;..\at32f415_board
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../user/: main.c
  group bsp
    ../at32f415_board/: at32f415_board.c at32f415_board.h at32f415_clock.c at32f415_int.c
  group driver
    ../libraries/drivers/src/: at32f415_gpio.c at32f415_misc.c at32f415_crm.c at32f415_dma.c at32f415_adc.c at32f415_usart.c at32f415_i2c.c at32f415_tmr.c at32f415_exint.c
  group cmsis
    ../libraries/cmsis/cm4/device_support/: system_at32f415.c
    ../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f415.s
